# Keil uVision project sendLiDAR.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: sendLiDAR
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: -u _printf_float
  c include: ..\sendLiDAR
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group YDLiDAR X4
    ./: v8stdint.h YDLidar.h YDLidar.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F407VGTx/STCubeGenerated/Src/: main.c stm32f4xx_it.c
    ./RTE/Device/STM32F407VGTx/STCubeGenerated/Inc/: stm32f4xx_it.h
software components: CMSIS:CORE 5.4.0, Device:STM32Cube HAL:Common 1.7.9, Device:STM32Cube HAL:Cortex 1.7.9, Device:STM32Cube HAL:DMA 1.7.9, Device:STM32Cube HAL:GPIO 1.7.9, Device:STM32Cube HAL:PWR 1.7.9, Device:STM32Cube HAL:RCC 1.7.9, Device:STM32Cube HAL:UART 1.7.9, Device:Startup 2.6.3
